# Autodesk Inventor assembly: Robot Base
## iProperties
Created: 2008-05
Part Number: Robot Base
Document SubType Name: Assembly
Designer: Jayson Martinez
Author: Jayson Martinez
